BRANCH = "ti-u-boot-2016.05"
SRC_URI = "git://github.com/zhengguang18282/uboot-ti.git;protocol=https;branch=${BRANCH}"
SRCREV = "${AUTOREV}"
